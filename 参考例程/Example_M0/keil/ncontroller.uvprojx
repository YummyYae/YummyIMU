# Keil uVision project ncontroller.uvprojx, settings and files
target ncontroller (6220000::V6.22::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: ncontroller +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __MSPM0G3507__,ARM_MATH_CM0
  c include: ..\source\third_party\CMSIS\Core\Include;..\source;..\;..\user\Task
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20200000 size 0x8000
  scatter file: .\mspm0g3507.sct
  group sources
    ../source/ti/driverlib/: dl_common.c dl_dma.c dl_uart.c
    ../source/ti/driverlib/m0p/sysctl/: dl_sysctl_mspm0g1x0x_g3x0x.c
    ../source/ti/devices/msp/m0p/startup_system_files/keil/: startup_mspm0g350x_uvision.s
  group user
    ../user/Task/: main.c
    ../user/BSP/: bsp_uart.c
    ../: ncontroller.syscfg ti_msp_dl_config.c ti_msp_dl_config.h
